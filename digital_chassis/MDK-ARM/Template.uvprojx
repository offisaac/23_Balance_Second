# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx,ARM_MATH_CM4,__CC_ARM,USE_MY_ASSERT,SWERVE_CHASSIS,USE_REFEREE_UI
  c misc: --cpp11
  c include: ../Core/Inc;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../USP;../SRML;../USP/Middlewares/Systemview;../Drivers/CMSIS/DSP/Include;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../USP/Middlewares/Robot_Module;../USP/Drivers/Lpms_Be2;../SRML/Middlewares/Module;../USP/Middlewares/abstract_class_library;../../digital_Power_LibraryFile;../USP/Drivers/MF9025_v2;../../abstract_class_library
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group SRML
    ../SRML/: srml_std_lib.cpp
  group SRML/Drivers/Components
    ../SRML/Drivers/Components/: drv_can.c drv_flash.c drv_i2c.c drv_spi.c drv_timer.c drv_uart.c
  group SRML/Drivers/Devices
    ../SRML/Drivers/Devices/MPU6050/: inv_mpu.c inv_mpu_dmp_motion_driver.c mpu_component.c mpu6050.c
    ../SRML/Drivers/Devices/: dr16.cpp motor_dji.h referee.cpp
  group SRML/Middlewares/Algorithm
    ../SRML/Middlewares/Algorithm/: filters.cpp PID.cpp
  group SRML/Middlewares/Module
    ../SRML/Middlewares/Module/: chassis.cpp power_ctrl.cpp
  group SRML/Middlewares/Protocol
    ../SRML/Middlewares/Protocol/: serial_line_ip.cpp
  group SRML/Middlewares/Utility
    ../SRML/Middlewares/Utility/: asuwave.c sys_analysis.cpp sys_log.cpp
  group USP
    ../USP/: srml_config.h
  group USP/Application
    ../USP/Application/: Service_Communication.cpp Service_Debug.cpp Service_Device.cpp System_Config.cpp System_DataPool.cpp
  group USP/Middlewares/Robot_Module
    ../USP/Middlewares/Robot_Module/: Balance_Chassis.cpp balance_controller.cpp FuzzyPD_Ctrl.cpp board_com.cpp source_manage.cpp Slider.cpp Slider_controller.cpp
  group USP/Middlewares/SystemView
    ../USP/Middlewares/Systemview/: SEGGER_RTT.c SEGGER_SYSVIEW.c SEGGER_SYSVIEW_Config_FreeRTOS.c SEGGER_SYSVIEW_FreeRTOS.c
  group USP/Middlewares/UpperMonitor
    ../USP/Middlewares/UpperMonitor/: UpperMonitor.cpp
  group USP/Drivers
    ../USP/Drivers/Lpms_Be2/: LPMS_BE2.cpp
    ../../digital_Power_LibraryFile/: digital_Power.cpp
    ../USP/Drivers/MF9025_v2/: MF9025_v2.cpp
  group USP/Middlewares/AbstractLib
    ../USP/Middlewares/abstract_class_library/: abstractIMU.h abstractMotor.h
